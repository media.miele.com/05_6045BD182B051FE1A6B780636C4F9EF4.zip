Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 793b08c7-025d-4a1e-a992-f0c5d64652ef, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:36:44+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10928050_B_DA4298W_EDST:28429850_B_10928050_DA4298W_EDST, (2)
In: Default
Type - Material: z_Miele_Design_Glass, Aluminum, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 898 mm; Depth: 500 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 28429850_B_10928050_DA4298W_EDST; sets with these values: 2
